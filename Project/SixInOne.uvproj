# Keil uVision project SixInOne.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: SixInOne +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: _DEBUG
  c include: ..\User;..\BSP
  group User
    ../User/: STARTUP.A51 main.c WorkProcess.c HMIProcess.c Interrupt.c Module_COMM.c HMI_COMM.c HMI_LL.c
  group BSP
    ../BSP/: STC_EEPROM.c crc.c DS18B20.c
